# IAR project Backup of VS210_AP.ewp, settings and files
configuration WHART (ARM, debug)
  General.OGChipSelectEditMenu: STM32L486RG ST STM32L486RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L486xx; PLL_CLOCK=PLL_64_MHZ; STANDARD=WHART
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Application\Interface; Application\SimpleApi; CMSIS; Globals; Hardware; Peripherals; Platform
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ISA100 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L486xx; PLL_CLOCK=PLL_64_MHZ; STANDARD=ISA100
  group Application
    ./: main.c
  group Application/Interface
    Application/Interface/: adc.c adc.h gpio.c gpio.h lpm.c lpm.h rtc.c rtc.h spi.c spi.h timers.c timers.h uart.c uart.h
  group Application/SimpleAPI
    Application/SimpleAPI/: simple_api.c simple_api.h
  group EWARM
    EWARM/: startup_stm32l486xx.s
  group Hardware
    Hardware/: hal_adc.h hal_aes.h hal_clock.h hal_flash.h hal_gpio.h hal_i2c.h hal_lib.a hal_lpm.h hal_lptim.h hal_rng.h hal_rtc.h hal_spi.h hal_timer.h hal_uart.h hal_wdt.h
  group Peripherals
    Peripherals/: SHT21.c SHT21.h
  group Platform
    Platform/: platform.c platform.h stm32l486xx.h stm32l4xx.h stm32l4xx_it.c stm32l4xx_it.h
